# Repository AvalonROV/Electrical

File README.txt:

This is the Avalon Electrical Team GitHub Repository. This Repository contains all of the software and hardware development files for the Avalon ROV (Remote Operated Vehicle).
For more information please visit our website: https://www.facebook.com/AvalonROV/

## KiCad design Hardware/Release Mechanism Board/ReleaseBoard.kicad_pcb

Schematic: ReleaseBoard.sch

Parts:
C1, C4, C8: C; C_Disc_D3.8mm_W2.6mm_P2.50mm
C2, C6, C9: 10n; C_Disc_D3.0mm_W1.6mm_P2.50mm
C3, C5, C7: C; CP_Radial_D5.0mm_P2.50mm
D1: 1N4841; D_DO-35_SOD27_P7.62mm_Horizontal
D2, D3: D; D_DO-41_SOD81_P7.62mm_Horizontal
F1: Fuse; Keystone20x5FuseHolder
J1: CONN_01X02; WireConnection_2.00mmDrill
J2, J5: CONN_01X02; WireConnection_1.00mmDrill
J3: CONN_02X03; Pin_Header_Straight_2x03_Pitch2.54mm
J4: CONN_02X04; Pin_Header_Straight_2x04_Pitch2.54mm
J6, J7: CONN_01X02; WireConnection_1.50mmDrill
Q1, Q2: Q_NMOS_GDS; TO-220-3_Vertical
R1, R2, R4, R6, R9: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R5: 12k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7, R13: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: 390k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R12: 8k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R14, R15, R16, R17, R18: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: LM7809CT; TO-92_Molded_Narrow
U2: LM324; DIP-14_W7.62mm
U3: LM78L05ACZ; TO-92_Molded_Narrow
U4: ATTINY85-20PU; DIP-8_W7.62mm

Connections:
+5V: C7.1, C8.1, J3.2, J5.1, U3.1, U4.8
+12V: C1.1, C5.1, D2.1, D3.1, F1.1, J6.1, J7.1, U1.1, U3.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J1.2, J2.2, J3.6, Q1.3, Q2.3, R2.2, R7.1, R9.2, R13.2, R14.2, R16.2, R18.2, U1.2, U2.11, U3.2, U4.4
unnamed: C2.1, R3.2
unnamed 4: C3.1, C4.1, R1.1, R10.1, U1.3, U2.4; also elsewhere on the board
unnamed: C6.1, R5.2
unnamed 6: C9.1, D1.1, R7.2, U2.9; also elsewhere on the board
unnamed: D1.2, R6.1, U2.7
unnamed: D2.2, J6.2, Q1.2
unnamed: D3.2, J7.2, Q2.2
unnamed: F1.2, J1.1
unnamed: J2.1, R1.2, R2.1, U2.3
unnamed: J3.1, J4.5, U4.6
unnamed: J3.3, J4.3, U4.7
unnamed: J3.4, J4.7, U4.5
unnamed: J3.5, U4.1
unnamed: J4.1, U4.2
unnamed: J4.2, R15.2
unnamed: J4.4, R12.2, R13.1
unnamed: J4.6, R17.2
unnamed: J4.8, J5.2, R14.1
unnamed: Q1.1, R15.1, R16.1
unnamed: Q2.1, R17.1, R18.1
unnamed: R3.1, R4.2, U2.2
unnamed: R4.1, U2.1, U2.5
unnamed: R5.1, R6.2, U2.6
unnamed: R9.1, R10.2, U2.10
unnamed: R12.1, U2.8

Board: 2 copper layers, 80.0 x 30.0 mm, 43 parts (0 on the bottom side), 28 nets.

Other parts of the board:
R8: 4.7M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Their connections:
unnamed 4: R8.1; also elsewhere on the board
unnamed 6: R8.2; also elsewhere on the board

## KiCad design Hardware/Topside Video Converter/Video Converter.kicad_pcb

Schematic: Video Converter.sch

Parts:
C1, C5, C6: C; C_Disc_D5.0mm_W2.5mm_P2.50mm
C2: C; CP_Radial_D5.0mm_P2.50mm
C3, C7: 68p; C_Disc_D3.0mm_W2.0mm_P2.50mm
C4: 10u; CP_Radial_D5.0mm_P2.50mm
C8: 1u; CP_Radial_D5.0mm_P2.50mm
J1: CONN_01X02; RS_5.5mmSocket
J2, J3: CONN_01X02; RCA_Jack_4890.2250
J4, J5: RJ45; TE_RJ45
R1, R4, R5, R6, R8, R11, R12, R13, R14, R17: 3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R9: 86R6; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R10: 3k9; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7, R15: 1k5; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R16, R18: 75R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R19, R20: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1, RV2: 1k; Potentiometer_Trimmer_Bourns_3266W
U1: LM7805; TO-220-3_Vertical
U2: LM2776; SOT-23-6
U3, U4: OPA2340; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+5V: C2.1, C6.1, U1.3, U2.3, U2.4, U3.8, U4.8
GND: C1.2, C2.2, C4.1, C5.1, C6.2, J1.1, J2.2, J3.2, J4.9, J5.9, R6.2, R14.2, U1.2, U2.2, U3.5, U4.5
unnamed: C1.1, J1.2, U1.1
unnamed: C3.1, R3.2
unnamed: C3.2, R1.2, R13.1, U3.1
unnamed: C4.2, C5.2, U2.1, U3.4, U4.4
unnamed: C7.1, R10.2
unnamed: C7.2, R8.2, R17.1, U4.1
unnamed: C8.1, U2.6
unnamed: C8.2, U2.5
unnamed: J2.1, R16.1
unnamed: J3.1, R18.1
unnamed: J4.1, J5.1
unnamed: J4.2, J5.2
unnamed: J4.3, J5.3
unnamed: J4.4, R19.1
unnamed: J4.5, R19.2
unnamed: J4.6, J5.6
unnamed: J4.7, R20.1
unnamed: J4.8, R20.2
unnamed: J5.4, R9.1, R11.2
unnamed: J5.5, R9.2, R12.2
unnamed: J5.7, R2.2, R5.2
unnamed: J5.8, R2.1, R4.2
unnamed: R1.1, R3.1, R7.2, U3.6
unnamed: R4.1, R6.1, U3.3
unnamed: R7.1, RV1.3
unnamed: R8.1, R10.1, R15.2, U4.6
unnamed: R11.1, R14.1, U4.3
unnamed: R12.1, R17.2, U4.2
unnamed: R5.1, R13.2, U3.2
unnamed: R15.1, RV2.3
unnamed: R16.2, RV1.1, RV1.2, U3.7
unnamed: R18.2, RV2.1, RV2.2, U4.7

Board: 2 copper layers, 49.0 x 59.5 mm, 39 parts (0 on the bottom side), 34 nets.

## KiCad design Hardware/Communication Board/avalon_communication_board.kicad_pcb

Parts:
C1, C14: 100uF; CP_Elec_6.3x7.7
C2: 1000uF; CP_Elec_8x10
C13: 100nF; C_1206_HandSoldering
C15: 330uF; CP_Elec_6.3x7.7
D1: BAT60BE; D_SOD-323
D2: 1N5819; D_SOD-123
D3, D4: LED; D_1206
JP1: Jumper; 0402
L1: 100uH; MSS1278T-334KLD
L3: 330uH; MSS1278T-334KLD
P1: MC34629; Socket_Strip_Straight_1x02_Pitch2.54mm
P2, P3, P4, P5: MC34633; Socket_Strip_Straight_1x04_Pitch2.54mm
P6: 6 Pin SIL; Socket_Strip_Straight_1x06_Pitch2.54mm
P7: 10 Pin SIL; Socket_Strip_Straight_1x10_Pitch2.54mm
P8, P9, P10, P11: 8 Pin SIL; Socket_Strip_Straight_1x08_Pitch2.54mm
P12: 2x3 Pin SIL; Socket_Strip_Straight_2x03_Pitch2.54mm
P19: Power Board Connector; JST_XH_B20B-XH-A_20x2.50mm_Straight
Q1, Q4: FMMT597; SOT-23
Q2, Q3, Q5: BC817; SOT-23
R1, R2, R4, R5, R37: 1.5K; R_1206_HandSoldering
R3, R6: 1K; R_1206_HandSoldering
R15, R16: 10K; R_1206_HandSoldering
R17, R36: 100K; R_1206_HandSoldering
R34: 100R; R_1206_HandSoldering
R35: 220R; R_1206_HandSoldering
SW1: B3U-1000P
U2: MPU9250
U3: LM2575S; TO-263-5_TabPin3
U4: ESP-12S; ESP12
V1: LM2576; TO-263-5_TabPin3

Connections:
+3V3: C2.1, C13.1, D3.2, L1.2, P2.1, P3.1, P3.2, P6.4, P10.4, R15.1, R16.1, R17.1, U2.3 (Vdd), U4.3 (EN), U4.8 (Vcc), V1.4 (F); also elsewhere on the board
+5V: C15.1, D4.2, L3.1, P4.3, P4.4, P5.1, U3.4 (F); also elsewhere on the board
+12V: C1.1, C14.1, P4.1, P4.2, P19.1, P19.2, Q1.3 (E), Q4.3 (E), R3.1, R6.1, U3.1 (Vin), V1.1 (Vin); also elsewhere on the board
BLUE_RX: P5.2, P9.5
BLUE_TX: P5.3, P9.6
ESP_SDA: P9.7, U2.2 (SDA), U4.11 (I2C_SDA)
Ether_CS': P7.8; also elsewhere on the board
Ether_R: P9.4
Ether_SCK: P12.4; also elsewhere on the board
Ether_SI: P12.3; also elsewhere on the board
Ether_SO: P12.2; also elsewhere on the board
GND: C1.2, C2.2, C13.2, C14.2, C15.2, D1.2 (A), D2.2 (A), JP1.2, P2.4, P3.3, P3.4, P5.4, P6.6, P10.6, P10.7, P19.3, P19.4, P19.5, Q2.3 (E), Q3.3 (E), Q5.3 (E), R34.2, R35.2, SW1.1, U2.4 (GND), U2.6 (FSYNC), U3.3 (GND), U3.5 (E), U4.9 (GND), V1.3 (GND), V1.5 (Enable); also elsewhere on the board
GPIO_11: P7.7, P19.12
GPIO_12: P7.6; also elsewhere on the board
GPIO_13: P7.5; also elsewhere on the board
GPIO_54: P11.1, P19.6
GPIO_55: P11.2, P19.7
GPIO_56: P11.3, P19.8
GPIO_57: P11.4, P19.9
GPIO_58: P11.5, P19.10
GPIO_59: P11.6, P19.11
GPIO_60: P11.7; also elsewhere on the board
GPIO_61: P11.8; also elsewhere on the board
unnamed: D1.1 (K), L1.1, V1.2 (Vout)
unnamed: D2.1 (K), L3.2, U3.2 (Vout)
unnamed: D3.1, R34.1
unnamed: D4.1, R35.1
unnamed: JP1.1, P19.20
unnamed: P1.1, Q3.2 (C), Q4.2 (C)
unnamed: P1.2, Q1.2 (C), Q2.2 (C)
unnamed: P6.2, U4.15 (RXD)
unnamed: P6.3, U4.16 (TXD)
unnamed: Q1.1 (B), R4.1
unnamed: Q2.1 (B), R5.2
unnamed: Q3.1 (B), R2.2
unnamed: Q4.1 (B), R1.1
unnamed: Q5.1 (B), R37.2
unnamed: Q5.2 (C), R3.2, R4.2, R5.1, R6.2
unnamed: R17.2, R36.2, SW1.2, U4.1 (RST), U4.12 (IO0)
unnamed: R36.1, U4.10 (IO15_(PWM))
POW_PWM_0: P7.9, P19.13
POW_PWM_1: P7.10, P19.14
POW_PWM_2: P8.1, P19.15
POW_PWM_3: P8.2, P19.16
POW_PWM_4: P8.3, P19.17
POW_PWM_5: P8.4, P19.18
POW_PWM_6: P8.5, P19.19
P_SCL: P2.3, P7.1, R15.2
P_SDA: P2.2, P7.2, R16.2

Notes on the sheet:
12 - 3.3VDC Regulator
Ultrasonic Transducer Driver Circuit
Ethernet Controller
MPU9250 Inertial Measurement Unit
Pressure Sensor
12 - 5V DC to DC Converter
Optional Bluetooth Connector
Power Breakout Connector
ESP8266 Microcontroller and WIFI
Arduino Due Connector
Power Board Connector
Camera Switching and Transmission Electronics
I2C - 0
I2C - 1

Parts:
C3, C4: 18pF; C_1206_HandSoldering
C5, C10, C11, C12: 0.1uF; C_1206_HandSoldering
C6: 10uF; C_1206_HandSoldering
C7, C8: 10nF; C_1206_HandSoldering
C9: 1nF; C_1206_HandSoldering
IC1: ENC28J60-I/SO; SOIC-28
J1: RJ45_LEDS; RJHSE-5381
L2: Ferrite_Bead; R_1206_HandSoldering
R7: 100K; R_1206_HandSoldering
R8: 2K; R_1206_HandSoldering
R9, R10, R11, R12: 50R; R_0603_HandSoldering
R13, R14: 100R; R_1206_HandSoldering
U1: B78476A8247A003
Y1: ABM3-25MHz; Crystal_SMD_5032-2pin_5.0x3.2mm_HandSoldering

Connections:
+3V3: C5.1, C10.1, C11.1, C12.1, IC1.15 (VDDTX), IC1.19 (VDDRX), IC1.20 (VDDPLL), IC1.25 (VDDOSC), IC1.28 (VDD), L2.1, R7.1; also elsewhere on the board
CAM1A: J1.8; also elsewhere on the board
CAM1B: J1.7; also elsewhere on the board
CAM2A: J1.4; also elsewhere on the board
CAM2B: J1.5; also elsewhere on the board
Ether_CS': IC1.9 (~CS); also elsewhere on the board
Ether_SCK: IC1.8 (SCK); also elsewhere on the board
Ether_SI: IC1.7 (SI); also elsewhere on the board
Ether_SO: IC1.6 (SO); also elsewhere on the board
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, IC1.2 (VSS), IC1.11 (VSSRX), IC1.18 (VSSTX), IC1.21 (VSSPLL), IC1.22 (VSSOSC), R8.2, R13.2, R14.1; also elsewhere on the board
LEDA: IC1.27 (LEDA), J1.12
LEDB: IC1.26 (LEDB), J1.10
unnamed: C3.1, IC1.23 (OSC1), Y1.1
unnamed: C4.1, IC1.24 (OSC2), Y1.2
unnamed: C6.1, IC1.1 (VCAP)
unnamed: C7.1, R9.2, R10.1
unnamed: C8.1, L2.2, R11.2, R12.1, U1.2 (TCT)
unnamed: C9.1, U1.15 (TXCT)
unnamed: IC1.10 (~RESET), R7.2
unnamed: IC1.12 (TPIN-), R12.2, U1.3 (TD-)
unnamed: IC1.13 (TPIN+), R11.1, U1.1 (TD+)
unnamed: IC1.14 (RBIAS), R8.1
unnamed: IC1.16 (TPOUT-), R10.2, U1.8 (RD-)
unnamed: IC1.17 (TPOUT+), R9.1, U1.6 (RD+)
unnamed: J1.1, U1.16 (TX+)
unnamed: J1.2, U1.14 (TX-)
unnamed: J1.3, U1.11 (RX+)
unnamed: J1.6, U1.9 (RX-)
unnamed: J1.9, R14.2
unnamed: J1.11, R13.1

Notes on the sheet:
Ethernet Controller

Parts:
C16, C23: 2.2uF; C_1206_HandSoldering
C17, C18, C19, C20, C21, C22, C25, C29, C31, C32: 0.1uF; C_1206_HandSoldering
C24: 1uF; C_1206_HandSoldering
C26, C27: 470uF; C_1206_HandSoldering
C28, C30: 47uF; CP_Elec_6.3x7.7
P13, P14, P15, P16, P17, P18: MC34631; Socket_Strip_Straight_1x03_Pitch2.54mm
R18, R19, R20, R21: 75R; R_1206_HandSoldering
R22, R23, R26, R27, R28, R29: 3K; R_1206_HandSoldering
R24, R25: 1.5K; R_1206_HandSoldering
R30, R31, R32, R33: 43R; R_1206_HandSoldering
U5: LM2776; SOT-23-6_Handsoldering
U6, U7: BH76330FVM; MSOP-8_3x3mm_Pitch0.65mm
U8, U9: LMH6643; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+5V: C16.1, C25.1, C28.1, C29.1, C30.1, C31.1, C32.1, U5.3, U5.4, U6.6, U7.6, U8.8, U9.8; also elsewhere on the board
+12V: P13.3, P14.3, P15.3, P16.3, P17.3, P18.3; also elsewhere on the board
-5V: C23.1, U5.1, U8.4, U9.4
CAM1A: R31.1; also elsewhere on the board
CAM1B: R30.1; also elsewhere on the board
CAM2A: R33.1; also elsewhere on the board
CAM2B: R32.1; also elsewhere on the board
GND: C16.2, C23.2, C25.2, C28.2, C29.2, C30.2, C31.2, C32.2, P13.1, P14.1, P15.1, P16.1, P17.1, P18.1, R20.2, R21.2, R22.2, R23.2, U5.2, U6.8, U7.8, U8.5 (+), U9.5 (+); also elsewhere on the board
GPIO_12: U6.4; also elsewhere on the board
GPIO_13: U6.2; also elsewhere on the board
GPIO_60: U7.2; also elsewhere on the board
GPIO_61: U7.4; also elsewhere on the board
unnamed: C17.1, U6.3
unnamed: C17.2, P17.2
unnamed: C18.1, U7.1
unnamed: C18.2, P13.2
unnamed: C19.1, P15.2
unnamed: C19.2, U7.5
unnamed: C20.1, P16.2
unnamed: C20.2, U6.1
unnamed: C21.1, U6.5
unnamed: C21.2, P18.2
unnamed: C22.1, U7.3
unnamed: C22.2, P14.2
unnamed: C24.1, U5.6
unnamed: C24.2, U5.5
unnamed: C26.1, U6.7
unnamed: C26.2, R19.1
unnamed: C27.1, U7.7
unnamed: C27.2, R18.1
unnamed: R18.2, R21.1, R25.2, U9.3 (+)
unnamed: R19.2, R20.1, R24.2, U8.3 (+)
unnamed: R22.1, R26.2, U8.2 (-)
unnamed: R23.1, R28.2, U9.2 (-)
unnamed: R24.1, R27.2, U8.6 (-)
unnamed: R25.1, R29.2, U9.6 (-)
unnamed: R26.1, R31.2, U8.1
unnamed: R27.1, R30.2, U8.7
unnamed: R28.1, R33.2, U9.1
unnamed: R29.1, R32.2, U9.7

Notes on the sheet:
5 to -5V Converter
Camera Video Switching and Transmission

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
Board: 2 copper layers, 100.0 x 62.1 mm, 115 parts (14 on the bottom side), 103 nets.

## Commit log

2017-12-22 -Added README file for repository
2017-12-22 -Created file for ROV PC Frontend -Created document outlining sections of research and planning for the PC Frontend
2017-12-24 -Additional Functions added to the Research Document -Dummy code written for currently planned functions -Random Number Generation function implemented, issues with numbers being generated always bei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
2017-12-27 Last year's UDP code
2018-01-02 -Created archive
2018-01-02 -Fixed issue with random numbers not going negative
2018-01-04 Add files via upload
    Provisional functions for comms. Header file yet to be created.
2018-01-31 -Updated Research Document to include ammended function requirements -Updated frontend cpp code to include ammended function requirements -Started development of function code
2018-02-05 Changed number of bytes per packet
2018-02-15 -KiCad Project Created
    -Created KiCad Project and Schematic
    -Started design of 12V to 3.3V DC Regulator
2018-02-16 -Changed voltage regulator part to 12 - 3.3VDC Buck Converter -Updated voltage regulator schematic for new Buck Converter with new components as per datasheet
2018-02-19 Started addition of Ultrasonic Transducer Control Circuitry
    -Started schematic for H Bridge Circuit to drive Ultrasonic Transducer
2018-02-22 -Ultrasonic Transducer Driver Circuit completed
2018-02-22 -Started production of Ethernet Controller Design -Updated Ultrasonic Transducer Driver Circuit to use 12V Supply instead of 5V Supply
2018-02-22 -Continued work on Ethernet Controller
2018-02-23 -Continued work on the ethernet controller
2018-02-24 -Ethernet Controller Main Schematic Updated
    -Main schematic almost complete with Pulse Transformers and Filtering
    -Capacitors for Crystal Oscillator need adding
    -Ethernet Controller schematic block added to main schematic sheet
2018-02-25 -Continued work on the Ethernet Controller Schematic
2018-02-26 -Ethernet controller schematic complete -Ferrite Bead component changed -Components selected and added to the communications board BOM, located in Google Drive -Filter Capacitor values changed to rec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
2018-02-28 -Started adding schematic symbol for ESP8266
2018-03-01 -Added Main Due Connector, 12 - 5V Regulator, I2C Bus Connections
2018-03-02 -Added the ESP8266 Microcontroller and support circuitry for programming
2018-03-02 -Arduino Due Connector completed
2018-03-02 -Updates made to Arduino Due Connector -Updates made to Ultrasonic Transducer Control Circuit -Moved schematic sections around to make space -Added camera electronics sub sheet
2018-03-03 -Added camera transmission and switching electronics
    -Added the camera switching chips from ROHM Semiconductor to enable
    switching between 6 different video channels
    -Added the camera transmission electronics taken from Blue Robotics
    -Added 5V to -5V converter to drive camera transmission electronics
2018-03-04 -Added a folder system to the hardware development folder for the different circuit board contained within the ROV -Added a PDF printout of the power board schematic
2018-03-04 -Completed wiring of Power Board Connector -Connected Camera Video Signals to RJ45 Connector
2018-03-04 no message
2018-03-05 -Fixed issue with -5V line in Camera Transmission electronics pointing upwards on schematic -Centred schematic layouts -Fixed issue where project file seemed to have been removed from the directory -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
2018-03-05 -Ran electrical rules check and made changes to the schematic to fix errors in connections, etc. -Updated PDF with new schematic.
2018-03-05 -Updated schematic sheet name and company name
2018-03-05 -Updated schematic PDF to reflect previous schematic updates
2018-03-06 -Started assigning footprints to components within schematic -Added jumper between separate grounds on power connector -Created footrprints for obscure parts
2018-03-08 -All footprints assigned to components apart from the MPU9250 IMU
2018-03-08 -Added Kicad PCB for communication board -Started component layout on PCB -Swapped some components for smaller SMD equivalents to improve PCB density -Started testing autorouting of board
2018-03-09 -Locked arduino header footprints to ensure they are not moved from their precise locations -Removed all footprints from board area to begin more optimal routing session
2018-03-11 -Layout and Routing complete for communication board -Silk Screen of board needs changing in order to produce a readable output -Design Rules file created -Footprint for MPU9250 created
2018-03-12 -Completed circuit board autorouting -Generated test Gerber files to check pricing of circuit board -Significantly reduced layout size through component placement optimization
2018-03-15 -Updated PCB layout to ensure decoupling capacitors are close to IC's -Re routed Arduino Due SPI connector to ensure pinout is correct
2018-03-17 -Moved capacitors for camera switching and transmission section to ensure decoupling operates correctly -Communication Board PCB Routing and Design Complete -Silk Screen of Communication Board modifi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
2018-03-17 -Updated schematic PDF to latest version
2018-03-17 -Added simulation file for ultrasonic transducer transmitter circuit
2018-03-17 -Fixed issue in ultrasonic transducer transmitter circuitry where transistor did not have base current limiting resistor -Updated PCB to account of additional resistor for ultrasonic transducer circu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
2018-03-17 -Updated schematic pdf to reflect changes
2018-03-19 -Added the Avalon Logo to the Communication Board PCB -Added the Avalon Logo Footprint File -Added the Avalon Logo to the Communication Board Schematic -Added the release mechanism circuit board file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
2018-03-20 -Completed Ultrasonic Receiver Circuit simulation -Modified Ultrasonic Receiver Circuit based upon simulation results
2018-03-21 -Release mechanism board updated with new peak detector design -Changes to release mechansim board PCB made -Added small version of Avalon logo -Regenerated release mechansim board gerber and drill f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
2018-03-21 -Updated release mecahnsim board with fuse
2018-03-21 -Added release mechansim board ZIP file
2018-03-21 -Updated release mechanism board with condensed design -Updated release mechanism board gerber files
2018-03-29 -Added Arduino Code for testing WIFI Signal Strength and Ping under water
2018-04-07 -Changed programming language from C++ to Python -Archived old C++ Files -Produced main ROV Communication class structure -Started laying out required methods for ROV communication -Implemented ROV c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
2018-04-07 -Implemented base communication functions
2018-04-09 -Added main ROV parameters to the ROV class ready for use in functions
2018-04-10 Removed possibility of comms check being skipped.
    and made it more concise.
2018-04-10 -Added custom module that handles the conversion of python values to c type binary values represented as python strings, this module can both convert to c type values and back from c type values -Add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
2018-04-11 -Started adding encoding functions to main frontend file
2018-04-12 -Removed unnecessary indexing storage variables -Started adding Input and Output functions that the Software team can use to interface with the ROV -Added ability to encode and decode characters to t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
2018-04-12 -Added ability to encode stabilisation flags into a single Byte
2018-04-16 -Implemented all core sending functionality
2018-04-19 -Added Ethernet Hardware Test Code
2018-04-21 -Added UDP Test Code
2018-04-22 Arduino code for video qualification
2018-04-23 -Small changes for hardware testing
2018-04-23 Modified recieved string
2018-04-24 Stepper control added
2018-04-24 -Test code for ENC28J60 Ethernet Controller, allows the reading of a control register to test hardware core functionality. Uses SPI communication and prewritten for Arduino Due.
2018-06-02 -Converted the test code to use the UIPEthernet Library for compatability with Arduino Due
2018-06-12 -Added additional test code for the Ethernet Controller -Added test code for the video switching functionality of the communication board
2018-06-12 -Added the Firmware File for the ESP8266 -Added the ultrasonic transducer driver functionality to the ESP8266 software
2018-06-14 -Updated ESP Software with I2C Communication of Webpage Data
2018-06-14 last update
2019-02-16 Create main_controller_2019
2019-02-17 Update main_controller_2019
